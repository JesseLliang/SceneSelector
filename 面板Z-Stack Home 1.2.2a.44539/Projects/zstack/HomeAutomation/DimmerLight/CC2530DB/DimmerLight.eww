<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DimmerLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DimmerLight</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>DimmerLight</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>DimmerLight</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>DimmerLight</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


