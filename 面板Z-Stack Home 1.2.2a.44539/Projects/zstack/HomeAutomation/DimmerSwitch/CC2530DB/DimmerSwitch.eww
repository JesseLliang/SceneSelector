<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DimmerSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>DimmerSwitch</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>DimmerSwitch</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>DimmerSwitch</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>DimmerSwitch</project>
        <configuration>EndDeviceEB - OTAClient</configuration>
      </member>
      <member>
        <project>DimmerSwitch</project>
        <configuration>RouterEB - OTAClient</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


